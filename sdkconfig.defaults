## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_CONNECT_WIFI=y
CONFIG_EXAMPLE_WIFI_SSID="Eugenexn"
CONFIG_EXAMPLE_WIFI_PASSWORD="12345678"
```
